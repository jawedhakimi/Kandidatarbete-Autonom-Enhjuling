# Repository jawedhakimi/Kandidatarbete-Autonom-Enhjuling

## KiCad design Kandidat_arbete.kicad_pcb

Parts:
C100, C101: 10u; C_0805_2012Metric; PARTREV C96446; JLC C96446
C104: 10nF; C_0805_2012Metric; PARTREV C57112
C108: 1uF; C_0805_2012Metric; PARTREV C28323
Cp102: 0u47F/50V; C_0805_2012Metric; PARTREV C13967
Cp103: 2u2F/50V; C_0805_2012Metric; PARTREV C49217
Cp105: 3u3F; C_0805_2012Metric; PARTREV C338093
Cp106: 0u1; C_0805_2012Metric; PARTREV C14663
Cp107: 22u/25; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; PARTREV C45783
D100: D_Zener_Small; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical; PARTREV C8062
D101, D103: RED; LED_0603_1608Metric; PARTREV C84256
D_Sch100: D_Schottky_Small; TO-277; PARTREV C8678; Mouser 637-SK35SMA
F100: 500mA; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical; PARTREV C8678
J1, J100: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
JP100: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
L100: 220u; L_Bourns_SRR1208_12.7x12.7mm; PARTREV C2929503; Mouser 652-SRR1208-221KL
Q100: BSP 171; bsp171; PARTREV C15127; Mouser 726-BSP171PH6327
R100: 10k; R_0603_1608Metric; PARTREV C25804
R102: 1k; R_0603_1608Metric; PARTREV C22764
R103: 127k; R_0603_1608Metric; PARTREV C25804
R104: 14k; R_0603_1608Metric; PARTREV C25804
R105: 47k; R_0603_1608Metric; PARTREV C25804
R106: 4M7; R_0603_1608Metric; PARTREV C25804
R107: 1k; R_0603_1608Metric; PARTREV C25804
R108: 499k; R_0603_1608Metric; PARTREV C25804
R109: 10k; R_0603_1608Metric; PARTREV C22764
RV1: R_Potentiometer_Small; TRIM_TC33X-2-103E
U1: LM5017MR; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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; PARTREV C34355; Mouser 926-LM5017MRX/NOPB
U101: LVR 3.3V; SOT-223-3_TabPin2; PARTREV C277892; Mouser 584-ADP3338AKCZ3.3R

Connections:
+3.3V: C101.1, D101.2 (A), U101.2 (VO); also elsewhere on the board
+5V: JP100.1 (A); also elsewhere on the board
+BATT: F100.1, J100.1
/Power circuitery/BST: C104.1, U1.7 (BST)
/Power circuitery/FB: Cp106.1, R107.2, RV1.2, RV1.3, U1.5 (FB)
/Power circuitery/LinReg_in: C100.1, JP100.2 (C), U101.3 (VI)
/Power circuitery/SW: C104.2, L100.1, R105.1, R106.1, U1.8 (SW)
/Power circuitery/ULVO: R103.1, R104.2, U1.3 (ULVO)
/Power circuitery/VCC_LM5017: C108.2, D_Sch100.3 (K), U1.6 (VCC)
GND: C100.2, C101.2, C108.1, Cp102.2, Cp103.2, Cp107.2, J1.2, J100.2, R100.2, R102.1, R104.1, R107.1, R109.1, U1.1 (RTN), U1.9 (RTNPAD), U101.1 (GND); also elsewhere on the board
unnamed: Cp105.1, Cp106.2, R105.2, R106.2
unnamed: D100.2 (A), Q100.1 (G), R100.1
unnamed: D100.1 (K), F100.2, Q100.3 (D)
unnamed: D101.1 (K), R102.2
unnamed: D103.1 (K), R109.2
unnamed: R108.2, U1.4 (RON)
SW_REG_OUT: Cp105.2, Cp107.1, D103.2 (A), D_Sch100.1 (A), D_Sch100.2 (A), J1.1, JP100.3 (B), L100.2, RV1.1
S_reg_in: Cp102.1, Cp103.1, Q100.2 (S), R103.2, R108.1, U1.2 (VIN)

Notes on the sheet:
Buck converter, 50V to 12V
5V comes from VBUS
Power Circuit
The Schottky diode is of type: B5819W SL https://jlcpcb.com/partdetail/9093-B5819WSL/C8598
The switching reg. XL1509-ADJE1 has input voltage og max 40V https://jlcpcb.com/partdetail/Xlsemi-XL1509_50E1/C61063
Linear Voltage reg. is of type: NCP1117ST33T3G https://uk.farnell.com/on-semiconductor/ncp1117st33t3g/ic-linear-voltage-regulator/dp/1652366?st=ldo%20regulator
Power indicating LED
Short circuit and Reverse input protection
P-channel mosfet 2N7002 https://jlcpcb.com/partdetail/9040-2N7002/C8545
The 47uH inductor is of type; CKST0605-47uH/M https://jlcpcb.com/partdetail/Cenker-CKST0605_47uHM/C3002654

Parts:
C200: 4u7; C_0805_2012Metric; PARTREV C29823; JLC C29823
C201, C202, C203, C204, C205, C212: 100n; C_0805_2012Metric; PARTREV C14663
C206: 1u; C_0805_2012Metric; PARTREV C15849
C207: 10n; C_0805_2012Metric; PARTREV C57112
C208, C209: 2u2; C_0603_1608Metric; PARTREV C23630
C210, C211: 12p; C_0805_2012Metric; PARTREV C38523
D200: Yellow; LED_0603_1608Metric; PARTREV C84256
D201: B; LED_0603_1608Metric; PARTREV C84256
D202: G; LED_0603_1608Metric; PARTREV C84256
D203: R; LED_0603_1608Metric; PARTREV C84256
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J2: USB_C_Receptacle_USB2.0; GCT_USB4105-GF-A
J3: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
J200: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J201, J203, J204, J205: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J207, J208: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
L200: 10u; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder; PARTREV C1051; Mouser 710-742792151
R200, R220: 10k; R_0603_1608Metric; PARTREV C25804
R201: 0; R_0603_1608Metric; PARTREV C22764
R202, R203: 2k2; R_0603_1608Metric; PARTREV C23162
R204, R205, R206, R207: 1k; R_0603_1608Metric; PARTREV C25804
R208, R209: 5k1; R_0603_1608Metric; PARTREV C25804
R405, R406, R407: 22; R_0603_1608Metric; PARTREV C227717
SW1: SW_Push; SW_SKRPACE010
SW200: BOOT0; SW_SPDT_PCM12
U200: STM32F405RGT6; LQFP-64_10x10mm_P0.5mm; PARTREV C15742; Mouser 511-STM32F405RGT6
U201: USBLC6-2SC6; SOT-23-6; PARTREV C5261088; Mouser 511-USBLC6-2SC6
Y200: 16Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm; PARTREV C13738; Mouser 815-ASEAIG-16MHZ-CST

Connections:
+3.3V: C200.1, C201.1, C202.1, C203.1, C204.1, C205.1, J3.1, J200.1, J201.1, J203.1, J204.1, J205.1, J207.1, J208.1, L200.1, R202.2, R203.2, R220.2, SW200.3 (C), U200.1 (VBAT), U200.19 (VDD), U200.32 (VDD), U200.48 (VDD), U200.64 (VDD); also elsewhere on the board
+3.3VA: C206.1, C207.1, L200.2, U200.13 (VDDA)
+5V: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U201.5 (VBUS); also elsewhere on the board
/STM32 and Connectivity/BOOT0: R200.2, U200.60 (BOOT0)
CAN1_RX: J201.2, U200.61 (PB8)
CAN1_TX: J201.3, U200.62 (PB9)
GND: C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, H1.1, H2.1, H3.1, H4.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.6, J200.3, J200.5, J200.9, J201.4, J203.4, J204.4, J205.4, J207.5, J208.5, R204.1, R205.1, R206.1, R207.1, R208.1, R209.1, SW1.1, SW200.1 (A), U200.12 (VSSA), U200.18 (VSS), U200.28 (PB2), U200.63 (VSS), U201.2 (GND), Y200.2, Y200.4; also elsewhere on the board
I2C2_SCL: J203.2, R202.1, U200.29 (PB10); also elsewhere on the board
I2C2_SDA: J203.3, R203.1, U200.30 (PB11); also elsewhere on the board
INT1: J208.2; also elsewhere on the board
INT2: J208.3; also elsewhere on the board
LED1: D200.2 (A), U200.53 (PC12)
LED2: D201.2 (A), U200.2 (PC13)
LED3: D202.2 (A), U200.3 (PC14)
LED4: D203.2 (A), U200.4 (PC15)
NRST: R220.1, R407.2, SW1.2, U200.7 (NRST)
unnamed: C211.1, R201.1, Y200.3
unnamed: D200.1 (K), R204.2
unnamed: D201.1 (K), R205.2
unnamed: D202.1 (K), R206.2
unnamed: D203.1 (K), R207.2
unnamed: J2.A5 (CC1), R208.2
unnamed: J2.B5 (CC2), R209.2
unnamed: J200.2, R405.1
unnamed: J200.4, R406.1
unnamed: C212.1, J200.10, R407.1
unnamed: R200.1, SW200.2 (B)
unnamed: C210.1, U200.5 (PH0), Y200.1
unnamed: R201.2, U200.6 (PH1)
unnamed: C208.1, U200.31 (VCAP_1)
unnamed: C209.1, U200.47 (VCAP_2)
PC0: J3.2, U200.8 (PC0)
PC1: J3.3, U200.9 (PC1)
PC2: J3.4, U200.10 (PC2)
PC3: J3.5, U200.11 (PC3)
SA0: J208.4; also elsewhere on the board
SWCLK: R406.2, U200.49 (PA14)
SWDIO: R405.2, U200.46 (PA13)
SWO: J200.6, U200.55 (PB3)
UART2_RX: J204.3, U200.17 (PA3)
UART2_TX: J204.2, U200.16 (PA2)
UART3_RX: J205.3, U200.52 (PC11)
UART3_TX: J205.2, U200.51 (PC10)
USB_CONN_D+: J2.A6 (D+), J2.B6 (D+), U201.3 (I/O2)
USB_CONN_D-: J2.A7 (D-), J2.B7 (D-), U201.1 (I/O1)
USB_D+: U200.45 (PA12), U201.4 (I/O2)
USB_D-: U200.44 (PA11), U201.6 (I/O1)

Notes on the sheet:
Interface and Connectivity
i2c pullups
C_load = 2*(C_cryst_load-C_stray_PCB), per side crystal pin. C_PCB ~= 6p
ESD protection
STM32 microcontroller
C_dec is 100nF per VDD and VBAT + 4.7uF

Parts:
C300: 0u22; C_0805_2012Metric; PARTREV C21122
C301: 4u7; C_0805_2012Metric; PARTREV C29823
C302: 4u7; C_0805_2012Metric; PARTREV C29823; JLC C29823
C303, C304, C305, C307: 0u1; C_0805_2012Metric; PARTREV C14663
C306: 10n; C_0805_2012Metric; PARTREV C57112
C308: 2n2; C_0805_2012Metric; PARTREV C1604
HMC5883: HMC5883L; PLCC16-0.5-3X3MM; MPN HMC5883L
J207: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
MMA8451: MMA8451QR1; QFN50P300X300X100-16N; MPN MMA8451QR1
MPU6050: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm; PARTREV C24112; Mouser 410-MPU-6050
R300: 10k; R_0603_1608Metric; PARTREV C25804
R301, R302: 100; R_0603_1608Metric; PARTREV C22775
R303: 22; R_0603_1608Metric; PARTREV C25804

Connections:
+3.3V: C302.1, C303.1, C305.1, C306.1, HMC5883.2 (2(VDD)), HMC5883.13 (13(VDDIO)), J207.1, MMA8451.1 (VDDIO), MMA8451.14 (VDD), MPU6050.8 (VDDIO), MPU6050.13 (VDD), R300.1, R301.1, R303.1; also elsewhere on the board
/Sensors/BYP: C304.1, MMA8451.2 (BYP)
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, HMC5883.9 (9(GND)), HMC5883.11 (11(GND)), J207.5, MMA8451.5 (GND_3), MMA8451.10 (GND_2), MMA8451.12 (GND), MPU6050.1 (CLKIN), MPU6050.11 (FSYNC), MPU6050.18 (GND), R302.1; also elsewhere on the board
I2C2_SCL: HMC5883.1 (1(SCL)), MMA8451.4 (SCL), MPU6050.23 (SCL); also elsewhere on the board
I2C2_SDA: HMC5883.16 (16(SDA)), MMA8451.6 (SDA), MPU6050.24 (SDA); also elsewhere on the board
INT1: MMA8451.11 (INT1); also elsewhere on the board
INT2: MMA8451.9 (INT2); also elsewhere on the board
MPU6050_AD0: MPU6050.9 (AD0), R301.2, R302.2
unnamed: HMC5883.4 (4(S1)), R303.2
unnamed: C300.2, HMC5883.8 (8(SETP))
unnamed: C301.1, HMC5883.10 (10(C1))
unnamed: C300.1, HMC5883.12 (12(SETC))
unnamed: C308.1, MPU6050.20 (CPOUT)
unnamed: C307.1, MPU6050.10 (REGOUT)
SA0: MMA8451.7 (SA0), R300.2; also elsewhere on the board

Notes on the sheet:
AD0 = 0, Adr: 1101000 AD0 = 1, Adr: 1101001
MPU6050
MMA8451QR1
HMC5883L
Regulator Filter Capacitor (Pin 10) 0.1µF ±10%, 2V VDD Bypass Capacitor (Pin 13) 0.1µF ±10%, 4V Charge Pump Capacitor (Pin 20) 2.2nF ±10%, 50V VLOGIC Bypass Capacitor (Pin 8) 10nF ±10%, 4V

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
Board: 4 copper layers, 100.0 x 75.0 mm, 98 parts (0 on the bottom side), 76 nets.

Other parts of the board:
J4: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical

Their connections:
+3.3V: J4.1; also elsewhere on the board
GND: J4.5; also elsewhere on the board

## Commit log

2023-05-15 pushat allt
